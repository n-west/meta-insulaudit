
FILESEXTRAPATHS_prepend := "${THISDIR}/linux-gumstix-3.5:"
SRC_URI += "file://usbnet-builtin.cfg"
